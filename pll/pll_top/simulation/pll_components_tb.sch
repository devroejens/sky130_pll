** sch_path: pll/pll_top/simulation/pll_components_tb.sch
**.subckt pll_components_tb
V1 vdd_0 gnd DC 1.8 PWL(0 0 10n 1.8)
Vmeas_vdd vdd_1 vdd_0 0
.save i(vmeas_vdd)
Vref clk_ctrl vss dc 0 pulse 0 1.8 8u 0.01n 0.01n 8u
Vfd rst vss dc 0 pulse 0 1.8 20n 0.1n 0.1n 10n 3600
Vmeas_vss vss_1 gnd 0
.save i(vmeas_vss)
Rvdd vdd vdd_1 10m m=1
Rvdd1 vss vss_1 10m m=1
Rdiv[0] vss div[0] 1m m=1
Rdiv[1] vss div[1] 1m m=1
Rdiv[2] vdd div[2] 1m m=1
Rdiv[3] vss div[3] 1m m=1
Rdiv[4] vss div[4] 1m m=1
Rdiv[5] vdd div[5] 1m m=1
Rdiv[6] vdd div[6] 1m m=1
Rdiv[7] vss div[7] 1m m=1
Rdiv[8] vss div[8] 1m m=1
Rdiv[9] vss div[9] 1m m=1
Rdiv[10] vss div[10] 1m m=1
Rdiv[11] vss div[11] 1m m=1
Rload[0] vss clk_out[0] 1meg m=1
Rload[1] vss clk_out[1] 1meg m=1
Rload[2] vss clk_out[2] 1meg m=1
Rload[3] vss clk_out[3] 1meg m=1
Rload[4] vss clk_out[4] 1meg m=1
Rload[5] vss clk_out[5] 1meg m=1
Rload[6] vss clk_out[6] 1meg m=1
Rload[7] vss clk_out[7] 1meg m=1
I0 ib_cp vss 25u
I1 vdd ib_vco 48u
C1 net1 vss 0.5p m=1
R1 net1 vcp 110k m=1
C2 vcp vss 75p m=1
I2 ib_buf vss 50u
x1 clk up rst clk_fb down vdd vss pll_pfd
x2 vdd down vcp ib_cp up rst vss pll_cp
x3 vdd vtune clk_out[0] clk_out[1] clk_out[2] clk_out[3] clk_out[4] clk_out[5] clk_out[6] clk_out[7]
+ ib_vco vss rst pll_vco
x4 vdd vss clk_fb clk_out[0] rst div[0] div[1] div[2] div[3] div[4] div[5] div[6] div[7] div[8]
+ div[9] div[10] div[11] pll_divider
x5 clk clk_ctrl vss vss pll_switch_freq_source vhigh=1.8 vlow=0 f1=15meg f2=20meg
Vref1 net2 vss 1.75
* noconn #net2
Cload[0] clk_out[0] vss 5f m=1
Cload[1] clk_out[1] vss 5f m=1
Cload[2] clk_out[2] vss 5f m=1
Cload[3] clk_out[3] vss 5f m=1
Cload[4] clk_out[4] vss 5f m=1
Cload[5] clk_out[5] vss 5f m=1
Cload[6] clk_out[6] vss 5f m=1
Cload[7] clk_out[7] vss 5f m=1
x6 vdd vcp rst vtune vtune ib_buf vss pll_lf_buf
**** begin user architecture code



*.option savecurrents
*.option rshunt = 1e12
*.option gmin = 1e-24

** Settings for better convergence
*.option reltol=0.01
*.option vntol=1e-3
*.option abstol=1e-9
*.option chgtol=1e-9
*.option trtol=10
*.option ITL4=500
*.option method=gear
*.option acct


.control

* #################################################################
* #
* #                         OPERATING POINT
* #
* #################################################################
reset
save all

op
set filetype=binary
write pll_components_tb.raw all

* #################################################################
* #
* #                 TRANSIENT OSCILATION REGIME
* #
* #################################################################
reset
setplot const
*save all
save v(vdd) v(vdd_1) v(vss) v(vss_1)
save v(clk_ctrl) v(clk) v(rst) v(clk_fb) v(up) v(down) v(vcp) v(vtune) v('clk_out<0>') v('clk_out<1>')
+ v('clk_out<2>') v('clk_out<3>') v('clk_out<4>') v('clk_out<5>') v('clk_out<6>') v('clk_out<7>')

stop when time = 100n
stop when time = 250n
stop when time = 500n
stop when time = 1u
stop when time = 2u
stop when time = 4u
stop when time = 6u

*tran 0.001n 8u uic
tran 50p 16u 0 5p uic
set filetype=ascii
write pll_components_tb_tran_100n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")
plot v(clk_ctrl)+30 v(rst)+28 v(clk)+26 v(clk_fb)+24 v(up)+22 v(down)+20 v(vcp)+18 v(vtune)+16
+ v("clk_out<0>")+14 v("clk_out<1>")+12 v("clk_out<2>")+10 v("clk_out<3>")+8 v("clk_out<4>")+6 v("clk_out<5>")+4
+ v("clk_out<6>")+2 v("clk_out<7>")+0

resume
set filetype=ascii
write pll_components_tb_tran_250n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")
plot v(clk_ctrl)+30 v(rst)+28 v(clk)+26 v(clk_fb)+24 v(up)+22 v(down)+20 v(vcp)+18 v(vtune)+16
+ v("clk_out<0>")+14 v("clk_out<1>")+12 v("clk_out<2>")+10 v("clk_out<3>")+8 v("clk_out<4>")+6 v("clk_out<5>")+4
+ v("clk_out<6>")+2 v("clk_out<7>")+0

resume
set filetype=ascii
write pll_components_tb_tran_500n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")
plot v(clk_ctrl)+30 v(rst)+28 v(clk)+26 v(clk_fb)+24 v(up)+22 v(down)+20 v(vcp)+18 v(vtune)+16
+ v("clk_out<0>")+14 v("clk_out<1>")+12 v("clk_out<2>")+10 v("clk_out<3>")+8 v("clk_out<4>")+6 v("clk_out<5>")+4
+ v("clk_out<6>")+2 v("clk_out<7>")+0

resume
set filetype=ascii
write pll_components_tb_tran_1000n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")
plot v(clk_ctrl)+30 v(rst)+28 v(clk)+26 v(clk_fb)+24 v(up)+22 v(down)+20 v(vcp)+18 v(vtune)+16
+ v("clk_out<0>")+14 v("clk_out<1>")+12 v("clk_out<2>")+10 v("clk_out<3>")+8 v("clk_out<4>")+6 v("clk_out<5>")+4
+ v("clk_out<6>")+2 v("clk_out<7>")+0

resume
set filetype=ascii
write pll_components_tb_tran_2000n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")

resume
set filetype=ascii
write pll_components_tb_tran_4000n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")

resume
set filetype=ascii
write pll_components_tb_tran_6000n.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp)
+ v(vtune) v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>")
+ v("clk_out<6>") v("clk_out<7>")

resume
set filetype=ascii
write pll_components_tb_tran.raw v(clk_ctrl) v(clk) v(clk_fb) v(rst) v(up) v(down) v(vcp) v(vtune)
+ v("clk_out<0>") v("clk_out<1>") v("clk_out<2>") v("clk_out<3>") v("clk_out<4>") v("clk_out<5>") v("clk_out<6>")
+ v("clk_out<7>")


* Plot outputs
plot v(clk_ctrl)+30 v(rst)+28 v(clk)+26 v(clk_fb)+24 v(up)+22 v(down)+20 v(vcp)+18 v(vtune)+16
+ v("clk_out<0>")+14 v("clk_out<1>")+12 v("clk_out<2>")+10 v("clk_out<3>")+8 v("clk_out<4>")+6 v("clk_out<5>")+4
+ v("clk_out<6>")+2 v("clk_out<7>")+0

*rusage
.endc



.options wnflag=1
.include $::SKYWATER_MODELS/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice
.include $::SKYWATER_MODELS/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice
.include $::SKYWATER_MODELS/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice
.include $::SKYWATER_MODELS/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice
.include $::SKYWATER_MODELS/models/corners/tt/nonfet.spice

.include $::SKYWATER_MODELS/cells/cap_var_hvt/sky130_fd_pr__cap_var_hvt.model.spice

* Mismatch parameters
.include $::SKYWATER_MODELS/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice
.include $::SKYWATER_MODELS/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice

* Resistor$::SKYWATER_MODELS/Capacitor
.include $::SKYWATER_MODELS/models/r+c/res_typical__cap_typical.spice
.include $::SKYWATER_MODELS/models/r+c/res_typical__cap_typical__lin.spice

* Special cells
.include $::SKYWATER_MODELS/models/corners/tt/specialized_cells.spice

* All models
.include $::SKYWATER_MODELS/models/all.spice

* Corner
.include $::SKYWATER_MODELS/models/corners/tt/rf.spice

* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_16.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_1.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_2.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_4.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_8.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_16.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_3.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_4.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_8.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice
.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice
.include $::SKYWATER_STDCELLS/cells/dfbbn/sky130_fd_sc_hd__dfbbn_1.spice
.include $::SKYWATER_STDCELLS/cells/dfbbn/sky130_fd_sc_hd__dfbbn_2.spice
.include $::SKYWATER_STDCELLS/cells/dfbbp/sky130_fd_sc_hd__dfbbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfbbn/sky130_fd_sc_hs__dfbbn_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfbbn/sky130_fd_sc_hs__dfbbn_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice
.include $::SKYWATER_STDCELLS/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrtp/sky130_fd_sc_hd__dfrtp_2.spice
.include $::SKYWATER_STDCELLS/cells/dfxbp/sky130_fd_sc_hd__dfxbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfxbp/sky130_fd_sc_hd__dfxbp_2.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_0.spice
.include $::SKYWATER_STDCELLS/cells/or3/sky130_fd_sc_hd__or3_1.spice
.include $::SKYWATER_STDCELLS/cells/nor2/sky130_fd_sc_hd__nor2_1.spice

**** end user architecture code
**.ends

* expanding   symbol:  pll_pfd/xschem/pll_pfd.sym # of pins=7
** sym_path: pll/pll_pfd/xschem/pll_pfd.sym
** sch_path: pll/pll_pfd/xschem/pll_pfd.sch
.subckt pll_pfd refclk up sdn fbclk down vdd vss
*.ipin refclk
*.ipin fbclk
*.opin up
*.opin down
*.ipin sdn
*.ipin vdd
*.ipin vss
x1 refclk vdd rst_3 vss vss vdd vdd up up_inv sky130_fd_sc_hd__dfrbp_2
x2 fbclk vdd rst_3 vss vss vdd vdd down down_inv sky130_fd_sc_hd__dfrbp_2
x6 rst_2 sdn_inv vss vss vdd vdd rst_3 sky130_fd_sc_hd__and2_2
x4 rst_0 vss vss vdd vdd rst_1 sky130_fd_sc_hd__buf_1
x5 rst_1 vss vss vdd vdd rst_2 sky130_fd_sc_hd__buf_1
x7 sdn vss vss vdd vdd sdn_inv sky130_fd_sc_hd__inv_1
**** begin user architecture code
* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_1.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_2.spice

.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_2.spice

.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice

.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice

.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice

.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice

.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice

**** end user architecture code
x3 up_inv down_inv vss vss vdd vdd rst_0 sky130_fd_sc_hd__or2_1
* noconn vss
* noconn vdd
.ends


* expanding   symbol:  pll_cp/xschem/pll_cp.sym # of pins=7
** sym_path: pll/pll_cp/xschem/pll_cp.sym
** sch_path: pll/pll_cp/xschem/pll_cp.sch
.subckt pll_cp vdd up icp ibias down sdn vss
*.ipin vdd
*.ipin vss
*.ipin up
*.ipin down
*.ipin ibias
*.ipin sdn
*.opin icp
**** begin user architecture code
* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_1.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_2.spice

.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_2.spice

.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice

.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice

.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice

.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice

.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice

**** end user architecture code
XM1 net1 vgn1 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vgn1 vgn2 net1 vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net2 vgn1 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 vgn2 vgn2 net2 vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 net3 net4 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 net4 vgp2 net3 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 net5 vgp1 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 vgp2 vgp2 net5 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 net6 net6 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net17 sdn net6 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 net7 vgn1 vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 net11 vgn2 net7 vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net8 vgn1 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net10 vgn2 net8 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 vgp1 sdnb vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM16 vgp2 sdnb vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM17 vgn1 sdn vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM18 vgn2 sdn vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x5 sdn vss vss vdd vdd sdnb sky130_fd_sc_hd__inv_1
XM19 vgn1 sdn net16 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM20 ibias sdn net9 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM21 net9 sdnb ibias vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
R1 vgp1 net4 10m m=1
Vmeas net4 net9 0
.save i(vmeas)
Vmeas1 vgp2 net16 0
.save i(vmeas1)
Vmeas2 net17 vgn2 0
.save i(vmeas2)
E1 icp_bias vss icp vss 1
x1 vdd net12 net13 up net14 net15 vss pll_cp_sw_clk_gen
x2 vdd net18 net19 down net20 net21 vss pll_cp_sw_clk_gen
x3 net10 net12 net13 net14 net15 vdd icp_bias icp vss pll_cp_sw_spdt
x4 net11 net21 net20 net19 net18 vdd icp_bias icp vss pll_cp_sw_spdt
.ends


* expanding   symbol:  pll_vco/xschem/pll_vco.sym # of pins=6
** sym_path: pll/pll_vco/xschem/pll_vco.sym
** sch_path: pll/pll_vco/xschem/pll_vco.sch
.subckt pll_vco vdd vtune vco_out[7] vco_out[6] vco_out[5] vco_out[4] vco_out[3] vco_out[2]
+ vco_out[1] vco_out[0] Ibias vss sdn
*.iopin vss
*.iopin vdd
*.iopin vtune
*.iopin Ibias
*.opin vco_out[0],vco_out[1],vco_out[2],vco_out[3],vco_out[4],vco_out[5],vco_out[6],vco_out[7]
*.iopin sdn
**** begin user architecture code


.control
save i(@m.${path}xm1.msky130_fd_pr__nfet_01v8[id])
save @m.${path}xm1.msky130_fd_pr__nfet_01v8[gm]
save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vds])
save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vgs])
save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vth])
save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vdsat])

save i(@m.${path}xm2.msky130_fd_pr__nfet_01v8[id])
save @m.${path}xm2.msky130_fd_pr__nfet_01v8[gm]
save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vds])
save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vgs])
save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vth])
save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vdsat])
.endc


**** end user architecture code
XM0 Ibias Ibias vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=10 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x5[0] phi[0] vss vss vdd vdd net1[7] sky130_fd_sc_hs__inv_1
x5[1] phi[1] vss vss vdd vdd net1[6] sky130_fd_sc_hs__inv_1
x5[2] phi[2] vss vss vdd vdd net1[5] sky130_fd_sc_hs__inv_1
x5[3] phi[3] vss vss vdd vdd net1[4] sky130_fd_sc_hs__inv_1
x5[4] phi[4] vss vss vdd vdd net1[3] sky130_fd_sc_hs__inv_1
x5[5] phi[5] vss vss vdd vdd net1[2] sky130_fd_sc_hs__inv_1
x5[6] phi[6] vss vss vdd vdd net1[1] sky130_fd_sc_hs__inv_1
x5[7] phi[7] vss vss vdd vdd net1[0] sky130_fd_sc_hs__inv_1
x6[0] net1[7] vss vss vdd vdd net2[7] sky130_fd_sc_hs__inv_2
x6[1] net1[6] vss vss vdd vdd net2[6] sky130_fd_sc_hs__inv_2
x6[2] net1[5] vss vss vdd vdd net2[5] sky130_fd_sc_hs__inv_2
x6[3] net1[4] vss vss vdd vdd net2[4] sky130_fd_sc_hs__inv_2
x6[4] net1[3] vss vss vdd vdd net2[3] sky130_fd_sc_hs__inv_2
x6[5] net1[2] vss vss vdd vdd net2[2] sky130_fd_sc_hs__inv_2
x6[6] net1[1] vss vss vdd vdd net2[1] sky130_fd_sc_hs__inv_2
x6[7] net1[0] vss vss vdd vdd net2[0] sky130_fd_sc_hs__inv_2
x7[0] net2[7] vss vss vdd vdd vco_out[0] sky130_fd_sc_hs__inv_4
x7[1] net2[6] vss vss vdd vdd vco_out[1] sky130_fd_sc_hs__inv_4
x7[2] net2[5] vss vss vdd vdd vco_out[2] sky130_fd_sc_hs__inv_4
x7[3] net2[4] vss vss vdd vdd vco_out[3] sky130_fd_sc_hs__inv_4
x7[4] net2[3] vss vss vdd vdd vco_out[4] sky130_fd_sc_hs__inv_4
x7[5] net2[2] vss vss vdd vdd vco_out[5] sky130_fd_sc_hs__inv_4
x7[6] net2[1] vss vss vdd vdd vco_out[6] sky130_fd_sc_hs__inv_4
x7[7] net2[0] vss vss vdd vdd vco_out[7] sky130_fd_sc_hs__inv_4
x1 phi[0] phi[4] phi[7] phi[3] vdd vtune Ibias vss sdn pll_vco_cell
x2 phi[1] phi[5] phi[0] phi[4] vdd vtune Ibias vss sdn pll_vco_cell
x3 phi[2] phi[6] phi[1] phi[5] vdd vtune Ibias vss sdn pll_vco_cell
x4 phi[3] phi[7] phi[2] phi[6] vdd vtune Ibias vss sdn pll_vco_cell
.ends


* expanding   symbol:  pll_divider/xschem/pll_divider.sym # of pins=6
** sym_path: pll/pll_divider/xschem/pll_divider.sym
** sch_path: pll/pll_divider/xschem/pll_divider.sch
.subckt pll_divider vdd vss clk_out clk_in sdn div[0] div[1] div[2] div[3] div[4] div[5] div[6]
+ div[7] div[8] div[9] div[10] div[11]
*.ipin clk_in
*.ipin div[0],div[1],div[2],div[3],div[4],div[5],div[6],div[7],div[8],div[9],div[10],div[11]
*.ipin sdn
*.opin clk_out
*.ipin vss
*.ipin vdd
**** begin user architecture code
* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_16.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_1.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_2.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_4.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_8.spice
.include $::SKYWATER_STDCELLS/cells/clkbuf/sky130_fd_sc_hd__clkbuf_16.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_3.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_4.spice
.include $::SKYWATER_STDCELLS/cells/decap/sky130_fd_sc_hd__decap_8.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice
.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_1.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice
.include $::SKYWATER_STDCELLS/cells/dfbbn/sky130_fd_sc_hd__dfbbn_1.spice
.include $::SKYWATER_STDCELLS/cells/dfbbn/sky130_fd_sc_hd__dfbbn_2.spice
.include $::SKYWATER_STDCELLS/cells/dfbbp/sky130_fd_sc_hd__dfbbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfbbn/sky130_fd_sc_hs__dfbbn_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfbbn/sky130_fd_sc_hs__dfbbn_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice
.include $::SKYWATER_STDCELLS/cells/dfrtp/sky130_fd_sc_hd__dfrtp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrtp/sky130_fd_sc_hd__dfrtp_2.spice
.include $::SKYWATER_STDCELLS/cells/dfxbp/sky130_fd_sc_hd__dfxbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfxbp/sky130_fd_sc_hd__dfxbp_2.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_0.spice
.include $::SKYWATER_STDCELLS/cells/or3/sky130_fd_sc_hd__or3_1.spice
.include $::SKYWATER_STDCELLS/cells/nor2/sky130_fd_sc_hd__nor2_1.spice
.include $::SKYWATER_STDCELLS/cells/nor3/sky130_fd_sc_hd__nor3_1.spice

**** end user architecture code
x1 clk_in net4 vdd vss vss vdd vdd net1 net63 sky130_fd_sc_hd__dfrbp_1
x2 clk_in net1 vdd vss vss vdd vdd net2 net64 sky130_fd_sc_hd__dfrbp_1
x4 clk_in net3 vdd vss vss vdd vdd net5 net65 sky130_fd_sc_hd__dfrbp_1
x5 net1 net6 vdd vss vss vdd vdd ps_out net6 sky130_fd_sc_hd__dfrbp_1
x3 ps_out net2 ps_mod vss vss vdd vdd net3 sky130_fd_sc_hd__or3_1
x6 net2 net5 vss vss vdd vdd net4 sky130_fd_sc_hd__nand2_1
x7 net52 net9 net7 net8 vss vss vdd vdd Q[0] net9 sky130_fd_sc_hd__dfbbp_1
x8 Q[0] net12 net10 net11 vss vss vdd vdd Q[1] net12 sky130_fd_sc_hd__dfbbp_1
x9 Q[1] net15 net13 net14 vss vss vdd vdd Q[2] net15 sky130_fd_sc_hd__dfbbp_1
x10 ps_out QN rs ss vss vss vdd vdd Q[3] QN sky130_fd_sc_hd__dfbbp_1
x11 Q[3] net18 net16 net17 vss vss vdd vdd Q[4] net18 sky130_fd_sc_hd__dfbbp_1
x12 Q[4] net21 net19 net20 vss vss vdd vdd Q[5] net21 sky130_fd_sc_hd__dfbbp_1
x13 Q[5] net24 net22 net23 vss vss vdd vdd Q[6] net24 sky130_fd_sc_hd__dfbbp_1
x14 Q[6] net27 net25 net26 vss vss vdd vdd Q[7] net27 sky130_fd_sc_hd__dfbbp_1
x15 Q[7] net30 net28 net29 vss vss vdd vdd Q[8] net30 sky130_fd_sc_hd__dfbbp_1
x16 Q[8] net33 net31 net32 vss vss vdd vdd Q[9] net33 sky130_fd_sc_hd__dfbbp_1
x17 Q[9] net36 net34 net35 vss vss vdd vdd Q[10] net36 sky130_fd_sc_hd__dfbbp_1
x18 Q[10] net39 net37 net38 vss vss vdd vdd Q[11] net39 sky130_fd_sc_hd__dfbbp_1
x19 rst_0_2 net40 vss vss vdd vdd net7 sky130_fd_sc_hd__nand2_1
x20 rst_0_2 div[0] vss vss vdd vdd net8 sky130_fd_sc_hd__nand2_1
x21 div[0] vss vss vdd vdd net40 sky130_fd_sc_hd__inv_1
x22 rst_0_2 net41 vss vss vdd vdd net10 sky130_fd_sc_hd__nand2_1
x23 rst_0_2 div[1] vss vss vdd vdd net11 sky130_fd_sc_hd__nand2_1
x24 div[1] vss vss vdd vdd net41 sky130_fd_sc_hd__inv_1
x25 rst_0_2 net42 vss vss vdd vdd net13 sky130_fd_sc_hd__nand2_1
x26 rst_0_2 div[2] vss vss vdd vdd net14 sky130_fd_sc_hd__nand2_1
x27 div[2] vss vss vdd vdd net42 sky130_fd_sc_hd__inv_1
x28 rst_3_11 net43 vss vss vdd vdd rs sky130_fd_sc_hd__nand2_1
x29 rst_3_11 div[3] vss vss vdd vdd ss sky130_fd_sc_hd__nand2_1
x30 div[3] vss vss vdd vdd net43 sky130_fd_sc_hd__inv_1
x31 rst_3_11 net44 vss vss vdd vdd net16 sky130_fd_sc_hd__nand2_1
x32 rst_3_11 div[4] vss vss vdd vdd net17 sky130_fd_sc_hd__nand2_1
x33 div[4] vss vss vdd vdd net44 sky130_fd_sc_hd__inv_1
x34 rst_3_11 net45 vss vss vdd vdd net19 sky130_fd_sc_hd__nand2_1
x35 rst_3_11 div[5] vss vss vdd vdd net20 sky130_fd_sc_hd__nand2_1
x36 div[5] vss vss vdd vdd net45 sky130_fd_sc_hd__inv_1
x37 rst_3_11 net46 vss vss vdd vdd net22 sky130_fd_sc_hd__nand2_1
x38 rst_3_11 div[6] vss vss vdd vdd net23 sky130_fd_sc_hd__nand2_1
x39 div[6] vss vss vdd vdd net46 sky130_fd_sc_hd__inv_1
x40 rst_3_11 net47 vss vss vdd vdd net25 sky130_fd_sc_hd__nand2_1
x41 rst_3_11 div[7] vss vss vdd vdd net26 sky130_fd_sc_hd__nand2_1
x42 div[7] vss vss vdd vdd net47 sky130_fd_sc_hd__inv_1
x43 rst_3_11 net48 vss vss vdd vdd net28 sky130_fd_sc_hd__nand2_1
x44 rst_3_11 div[8] vss vss vdd vdd net29 sky130_fd_sc_hd__nand2_1
x45 div[8] vss vss vdd vdd net48 sky130_fd_sc_hd__inv_1
x46 rst_3_11 net49 vss vss vdd vdd net31 sky130_fd_sc_hd__nand2_1
x47 rst_3_11 div[9] vss vss vdd vdd net32 sky130_fd_sc_hd__nand2_1
x48 div[9] vss vss vdd vdd net49 sky130_fd_sc_hd__inv_1
x49 rst_3_11 net50 vss vss vdd vdd net34 sky130_fd_sc_hd__nand2_1
x50 rst_3_11 div[10] vss vss vdd vdd net35 sky130_fd_sc_hd__nand2_1
x51 div[10] vss vss vdd vdd net50 sky130_fd_sc_hd__inv_1
x52 rst_3_11 net51 vss vss vdd vdd net37 sky130_fd_sc_hd__nand2_1
x53 rst_3_11 div[11] vss vss vdd vdd net38 sky130_fd_sc_hd__nand2_1
x54 div[11] vss vss vdd vdd net51 sky130_fd_sc_hd__inv_1
x55 Q[2] Q[1] vss vss vdd vdd net53 sky130_fd_sc_hd__or2_0
x56 net53 Q[0] vss vss vdd vdd ps_mod sky130_fd_sc_hd__nor2_1
x58 ps_mod vss vss vdd vdd net54 sky130_fd_sc_hd__inv_1
x59 Q[11] Q[10] vss vss vdd vdd net58 sky130_fd_sc_hd__or2_0
x60 net58 Q[9] vss vss vdd vdd net60 sky130_fd_sc_hd__or2_0
x61 net60 Q[8] vss vss vdd vdd net61 sky130_fd_sc_hd__or2_0
x62 net61 Q[7] vss vss vdd vdd net62 sky130_fd_sc_hd__or2_0
x63 net62 Q[6] vss vss vdd vdd net57 sky130_fd_sc_hd__or2_0
x64 net57 Q[5] vss vss vdd vdd net56 sky130_fd_sc_hd__or2_0
x65 net56 Q[4] vss vss vdd vdd net55 sky130_fd_sc_hd__or2_0
x66 net55 Q[3] vss vss vdd vdd div_rst sky130_fd_sc_hd__nor2_1
x67 int_rst sdn div_rst vss vss vdd vdd div_rst_b sky130_fd_sc_hd__nor3_1
x68 div_rst_b vss vss vdd vdd rst_3_11 sky130_fd_sc_hd__inv_2
x69 div_rst_b vss vss vdd vdd rst_0_2 sky130_fd_sc_hd__inv_2
x70 div_rst vdd net59 vss vss vdd vdd int_rst sky130_fd_sc_hd__dfrtp_1
x71 int_rst ps_out_b vss vss vdd vdd net59 sky130_fd_sc_hd__nand2_1
x73 ps_out_b div_rst_b vss vss vdd vdd net66 clk_out sky130_fd_sc_hd__dfxbp_1
x72 ps_out vss vss vdd vdd ps_out_b sky130_fd_sc_hd__inv_2
x57 net54 ps_out vss vss vdd vdd net52 sky130_fd_sc_hd__and2_2
* noconn vss
* noconn vdd
* noconn #net65
* noconn #net64
* noconn #net63
* noconn #net66
.ends


* expanding   symbol:  pll_switch_freq_source/xschem/pll_switch_freq_source.sym # of pins=4
** sym_path: pll/pll_switch_freq_source/xschem/pll_switch_freq_source.sym
** sch_path: pll/pll_switch_freq_source/xschem/pll_switch_freq_source.sch
.subckt pll_switch_freq_source out1 in1 in0 out0  vhigh=1.8 vlow=0 f1=10meg f2=11meg
*.iopin out1
*.iopin out0
*.ipin in1
*.ipin in0
Vref_f2 clk_f2 out0 dc 0 pulse vlow vhigh {1/f2/2} 0.1n 0.1n {1/f2/2} {1/f2}
Vref_f1 clk_f1 out0 dc 0 pulse vlow vhigh {1/f1/2} 0.1n 0.1n {1/f1/2} {1/f1}
S1 out1 clk_f1 in0 in1 switch_clk_b
S2 out1 clk_f2 in1 in0 switch_clk
**** begin user architecture code


.model switch_clk sw vt=0.9 vh=0.2 ron=1m roff=1g
.model switch_clk_b sw vt=-0.9 vh=0.2 ron=1m roff=1g


**** end user architecture code
.ends


* expanding   symbol:  pll_lf_buf/xschem/pll_lf_buf.sym # of pins=7
** sym_path: pll/pll_lf_buf/xschem/pll_lf_buf.sym
** sch_path: pll/pll_lf_buf/xschem/pll_lf_buf.sch
.subckt pll_lf_buf vdd vin_p sdn vin_n vout ibias vss
*.iopin vss
*.iopin vdd
*.ipin vin_p
*.ipin vin_n
*.iopin ibias
*.opin vout
*.ipin sdn
XM1 net4 vin_p net1 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM2 net5 vin_n net1 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM3 vbn vbp_casc net2 vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM4 vout vbp_casc net3 vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM5 net2 vbp vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM6 net3 vbp vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM7 vbn vbn_casc net4 vss sky130_fd_pr__nfet_01v8 L=0.3 W=8 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM8 vout vbn_casc net5 vss sky130_fd_pr__nfet_01v8 L=0.3 W=8 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM9 net4 vbn vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=8 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM10 net5 vbn vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=8 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM11 net1 vbp vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=8 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=8 m=8
XM12 net9 net10 vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net6 vbp vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net10 net8 net9 vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 vbn_casc vbp_casc net6 vdd sky130_fd_pr__pfet_01v8 L=0.3 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM16 vbn_casc vbn_casc vss vss sky130_fd_pr__nfet_01v8 L=1.2 W=4 nf=2 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM17 net7 vbn_casc vss vss sky130_fd_pr__nfet_01v8 L=1.2 W=4 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM18 net7 net7 vdd vdd sky130_fd_pr__pfet_01v8 L=1.2 W=16 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM19 vbn sdn vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM20 vbn_casc sdn vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM21 vbp sdn_b vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM22 vbp_casc sdn_b vdd vdd sky130_fd_pr__pfet_01v8 L=0.3 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM23 net8 sdn_b ibias vss sky130_fd_pr__nfet_01v8 L=0.15 W=4 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
**** begin user architecture code

.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice

**** end user architecture code
x1 sdn vss vss vdd vdd sdn_b sky130_fd_sc_hd__inv_1
R1 net10 net8 8k m=1
R2 vbp_casc net8 1 m=1
R3 vbp net10 1 m=1
XM24 ibias sdn net8 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=12 nf=8 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  pll_cp_sw_clk_gen/xschem/pll_cp_sw_clk_gen.sym # of pins=7
** sym_path: pll/pll_cp_sw_clk_gen/xschem/pll_cp_sw_clk_gen.sym
** sch_path: pll/pll_cp_sw_clk_gen/xschem/pll_cp_sw_clk_gen.sch
.subckt pll_cp_sw_clk_gen vdd phase1 phase1b clk_in phase2 phase2b vss
*.ipin vdd
*.ipin vss
*.ipin clk_in
*.opin phase1
*.opin phase1b
*.opin phase2
*.opin phase2b
x1 net1 vdd vss clk_in net2 pll_nol_clkb
x2 phase2 vdd vss net2 phase2b pll_sync_clkb
x3 phase1 vdd vss net1 phase1b pll_sync_clkb
.ends


* expanding   symbol:  pll_cp_sw_spdt/xschem/pll_cp_sw_spdt.sym # of pins=9
** sym_path: pll/pll_cp_sw_spdt/xschem/pll_cp_sw_spdt.sym
** sch_path: pll/pll_cp_sw_spdt/xschem/pll_cp_sw_spdt.sch
.subckt pll_cp_sw_spdt cm phase1 phase1b phase2 phase2b vdd out1 out2 vss
*.ipin vdd
*.ipin vss
*.ipin phase1
*.ipin phase1b
*.ipin phase2
*.ipin phase2b
*.ipin cm
*.opin out2
*.opin out1
XM1 cm phase1 out1 vss sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 cm phase1b out1 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 cm phase2 out2 vss sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 cm phase2b out2 vdd sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  pll_vco_cell/xschem/pll_vco_cell.sym # of pins=9
** sym_path: pll/pll_vco_cell/xschem/pll_vco_cell.sym
** sch_path: pll/pll_vco_cell/xschem/pll_vco_cell.sch
.subckt pll_vco_cell out_n out_p in_p in_n vdd vtune vbias vss sdn
*.iopin vss
*.iopin vdd
*.ipin in_p
*.ipin in_n
*.iopin vbias
*.opin out_n
*.opin out_p
*.ipin vtune
*.ipin sdn
**** begin user architecture code


*.control
*save i(@m.${path}xm1.msky130_fd_pr__nfet_01v8[id])
*save @m.${path}xm1.msky130_fd_pr__nfet_01v8[gm]
*save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vds])
*save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vgs])
*save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vth])
*save v(@m.${path}xm1.msky130_fd_pr__nfet_01v8[vdsat])

*save i(@m.${path}xm2.msky130_fd_pr__nfet_01v8[id])
*save @m.${path}xm2.msky130_fd_pr__nfet_01v8[gm]
*save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vds])
*save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vgs])
*save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vth])
*save v(@m.${path}xm2.msky130_fd_pr__nfet_01v8[vdsat])
*.endc


**** end user architecture code
XM3 net1 vbias vss vss sky130_fd_pr__nfet_01v8 L=0.3 W=60 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=4 m=4
XM10 vbias sdn vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 sdn vss vss vdd vdd net2 sky130_fd_sc_hd__inv_1
x2 sdn vss vss vdd vdd net3 sky130_fd_sc_hd__inv_1
XM4 out_n out_n vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 out_p out_p vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 out_p out_n vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=16 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 out_n out_p vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=16 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 out_n net2 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 out_p net3 vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 out_n in_p net1 vss sky130_fd_pr__nfet_01v8 L=0.15 W=16 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 out_p in_n net1 vss sky130_fd_pr__nfet_01v8 L=0.15 W=16 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XC1 out_n vtune vss sky130_fd_pr__cap_var_lvt W=7 L=4 VM=3 m=3
XC2 out_p vtune vss sky130_fd_pr__cap_var_lvt W=7 L=4 VM=3 m=3
.ends


* expanding   symbol:  pll_nol_clkb/xschem/pll_nol_clkb.sym # of pins=5
** sym_path: pll/pll_nol_clkb/xschem/pll_nol_clkb.sym
** sch_path: pll/pll_nol_clkb/xschem/pll_nol_clkb.sch
.subckt pll_nol_clkb clk1 vdd vss clk clk2
*.opin clk1
*.opin clk2
*.ipin vdd
*.ipin vss
*.ipin clk
**** begin user architecture code
* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_1.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_2.spice

.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/nand2/sky130_fd_sc_hs__nand2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/nand2/sky130_fd_sc_hs__nand2_2.spice

.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_2.spice

.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice

.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice

.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice

.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice

.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice

**** end user architecture code
x3 clk1b vss vss vdd vdd clk1 sky130_fd_sc_hd__inv_1
x4 clk1 vss vss vdd vdd clk1fb sky130_fd_sc_hd__inv_1
x5 clk2b vss vss vdd vdd clk2 sky130_fd_sc_hd__inv_1
x6 clk2 vss vss vdd vdd clk2fb sky130_fd_sc_hd__inv_1
x7 clk vss vss vdd vdd clkb sky130_fd_sc_hd__inv_1
x1 clkb clk2fb vss vss vdd vdd clk1b sky130_fd_sc_hd__nand2_2
x2 clk1fb clk vss vss vdd vdd clk2b sky130_fd_sc_hd__nand2_2
* noconn vdd
* noconn vss
.ends


* expanding   symbol:  pll_sync_clkb/xschem/pll_sync_clkb.sym # of pins=5
** sym_path: pll/pll_sync_clkb/xschem/pll_sync_clkb.sym
** sch_path: pll/pll_sync_clkb/xschem/pll_sync_clkb.sch
.subckt pll_sync_clkb out_clk vdd vss in_clk out_clkb
*.opin out_clk
*.opin out_clkb
*.ipin vdd
*.ipin vss
*.ipin in_clk
**** begin user architecture code
* .include $::SKYWATER_STDCELLS/cells/
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_1.spice
.include $::SKYWATER_STDCELLS/cells/and2/sky130_fd_sc_hd__and2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/and2/sky130_fd_sc_hs__and2_2.spice

.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/nand2/sky130_fd_sc_hs__nand2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/nand2/sky130_fd_sc_hs__nand2_2.spice

.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_1.spice
.include $::SKYWATER_STDCELLS/cells/or2/sky130_fd_sc_hd__or2_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/or2/sky130_fd_sc_hs__or2_2.spice

.include $::SKYWATER_STDCELLS/cells/buf/sky130_fd_sc_hd__buf_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/buf/sky130_fd_sc_hs__buf_1.spice

.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_1.spice
.include $::SKYWATER_STDCELLS/cells/dfrbp/sky130_fd_sc_hd__dfrbp_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/dfrbp/sky130_fd_sc_hs__dfrbp_2.spice

.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_1.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_2.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_4.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_8.spice
.include $::SKYWATER_STDCELLS/cells/inv/sky130_fd_sc_hd__inv_16.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_1.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_2.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_4.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_8.spice
.include $::SKYWATER_STDCELLS_HS/cells/inv/sky130_fd_sc_hs__inv_16.spice

.include $::SKYWATER_STDCELLS/cells/mux2/sky130_fd_sc_hd__mux2_2.spice
.include $::SKYWATER_STDCELLS/cells/nand2/sky130_fd_sc_hd__nand2_1.spice

.include $::SKYWATER_STDCELLS/cells/tap/sky130_fd_sc_hd__tap_2.spice
.include $::SKYWATER_STDCELLS/cells/tapvpwrvgnd/sky130_fd_sc_hd__tapvpwrvgnd_1.spice

**** end user architecture code
x1 in_clk vss vss vdd vdd net1 sky130_fd_sc_hd__inv_2
x2 net1 vss vss vdd vdd net2 sky130_fd_sc_hd__inv_2
x4 stor_node vss vss vdd vdd out_clk sky130_fd_sc_hd__inv_1
x6 stor_node_b vss vss vdd vdd out_clkb sky130_fd_sc_hd__inv_1
x7 stor_node_b vss vss vdd vdd stor_node sky130_fd_sc_hd__inv_2
x9 stor_node vss vss vdd vdd stor_node_b sky130_fd_sc_hd__inv_2
x3 net2 vss vss vdd vdd stor_node sky130_fd_sc_hd__inv_1
x5 net1 vss vss vdd vdd stor_node_b sky130_fd_sc_hd__inv_1
* noconn vdd
* noconn vss
.ends

.GLOBAL gnd
.end
